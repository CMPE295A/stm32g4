# Keil uVision project Project.uvprojx, settings and files
target STM32WB55RG_Nucleo_Chacha-Poly1305_AuthEncrypt_VerifDecrypt (6140000::V6.14::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx.0.0.7
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x2002FC03) IRAM2(0x20030000-0x200327FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WB55xx,USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,CORE_CM4
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_Cryptographic/include;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/User
    ../Src/: stm32wbxx_it.c stm32wbxx_hal_msp.c cmox_low_level.c main.c
  group Doc
    ../: readme.txt
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Middlewares/STM32Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM4.a
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
software components: CMSIS:CORE 5.4.0
