# IAR project Project.ewp, settings and files
configuration NUCLEO-L073RZ_ChaCha20-Poly1305_AEAD_EncryptDecrypt (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L073xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L073RZ-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c cmox_low_level.c main.c
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Middlewares/STM32Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM0_CM0PLUS.a
