# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-U575ZI-Q_ECDSA_SignVerify (6140001::V6.14.1::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.0.5
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U575xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32U5xx_Nucleo;../../../../../../Middlewares/ST/STM32_Cryptographic/include;../../../../../../Drivers/BSP/STM32U5xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/User
    ../Src/: stm32u5xx_it.c stm32u5xx_hal_msp.c cmox_low_level.c main.c
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_icache.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c
  group Drivers/BSP/STM32U5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/STM32Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM33.a
software components: CMSIS:CORE 4.3.0
