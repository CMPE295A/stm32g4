# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G474RE_AES_CBC_EncryptDecrypt (6140000::V6.14::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G474xx,USE_HAL_DRIVER,USE_STM32G4XX_NUCLEO,USE_NUCLEO_64,USE_NUCLEO_64
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_Cryptographic/include;../../../../../../Drivers/BSP/STM32G4xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/User
    ../Src/: stm32g4xx_it.c stm32g4xx_hal_msp.c cmox_low_level.c main.c
  group Doc
    ../: readme.txt
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_exti.c
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/STM32Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM4.a
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
software components: CMSIS:CORE 5.4.0
